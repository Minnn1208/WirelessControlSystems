# Keil uVision project 24c20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 24c20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\24c02;.\App\iic;.\App\serial_debug;.\Public
  group 24c02
    ./App/24c02/: 24c02.c
  group iic
    ./App/iic/: iic.c
  group serial_debug
    ./App/serial_debug/: serial_debug.c
  group User
    ./User/: main.c
  group public
    ./Public/: public.c
